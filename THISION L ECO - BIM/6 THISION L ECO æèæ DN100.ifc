Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-12-12T17:15:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Dec 12 17:15:16 2018 * Host: B3ROBRAWR2788 * Database: C:\Users\AVIT\AppData\Local\Temp\{33950D90-0154-45E6-89F7-2533FF1986B5}\ifc * Database version: 5507 * Database creation date: Wed Dec 12 17:15:13 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Dec 12 17:15:14 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Dec 12 17:15:14 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBoiler: DN100 B2B_6, HC_Boiler_MEPcontent_Elco_ThisionCascade_6 Boiler_Back to Back_DN100_INT-EN:DN100 B2B_6:1386167
In: V00
Type - Material: Color RGB 127-127-127, Color RGB 040-040-040, Color RAL 7035, Color RGB 134-123-049, Color RAL 9016, Color RGB 245-197-044, Color RGB 023-097-171, Color RGB 178-000-000
Type - Dimensions - Condensate Connection Diameter: 22 mm; Equipment Depth: 1000 mm; Equipment Height: 1714 mm; Equipment Width: 2130 mm; Flue Connection Diameter: 100 mm; Gas Connection Diameter: 25 mm; Gas Header Diameter: 76.1 mm; HTG Connection Diameter: 32 mm; HTGF Spigot Diameter: 48.3 mm; HTG Header Diameter: 114.5 mm; HTGR Spigot Diameter: 48.3 mm; HTG Spigot Diameter: 35 mm
Type - Electrical - Equipment Power Factor: 0.9; Voltage: 230 V
Type - General - Created By: JDGA; Issue Date: 21-10-16; Issue Rev: A
Type - Identity Data - Article Type: DN100 B2B_6; Base Family Version: 11.22; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: 6 Boiler Cascade, Back to Back, DN100; EMCS Version: 4.0; ETIM Article Class: EC011755; Family Version: 11.22; GLN: 8714231770244; Manufacturer: Elco; MEPcontent Class: BOILER; Model: DN100 B2B_6; OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Revit Version: 2017; Type Comments: 6 Boiler Cascade, Back to Back, DN100; Type Name: DN100 B2B_6; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Blue: Color RGB 023-097-171; Bronze: Color RGB 134-123-049; Red: Color RGB 178-000-000; Yellow: Color RGB 245-197-044
Type - Mechanical - Water Content HTG: 0 m3
Type - Other - Category: Mechanical Equipment; Boiler Type 100: TH-L ECO-100; Boiler Type 120: TH-L ECO-120; Boiler Type 70: TH-L ECO-70; Family Name: HC_Boiler_MEPcontent_Elco_ThisionCascade_6 Boiler_Back to Back_DN100_INT-EN; Weight Dry: 0; Weight Operating: 0
Type - Text - Article Description: 6 Boiler Cascade, Back to Back, DN100; Product Line: Elco
Pset_ManufacturerTypeInformation - Manufacturer: Elco
Constraints - Offset: 0 mm
Dimensions - Area: 16.6235 m2; Gas Spigot Diameter: 33.7 mm; Volume: 1.97568 m3
Electrical - Equipment Apparent Power: 82.2 W
Identity Data - Mark: 4
Mechanical - Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Other,Hydronic Supply,Hydronic Return,Hydronic Supply,Hydronic Return,Power,Sanitary,Other Air,Power,Sanitary,Other Air,Power,Sanitary,Other Air,Power,Sanitary,Other Air,Power,Sanitary,Other Air,Power,Sanitary,Other Air
Other - Boiler Type 100: no; Boiler Type 120: no; Boiler Type 70: yes; Family: HC_Boiler_MEPcontent_Elco_ThisionCascade_6 Boiler_Back to Back_DN100_INT-EN: DN100 B2B_6; Family and Type: HC_Boiler_MEPcontent_Elco_ThisionCascade_6 Boiler_Back to Back_DN100_INT-EN: DN100 B2B_6; Type: HC_Boiler_MEPcontent_Elco_ThisionCascade_6 Boiler_Back to Back_DN100_INT-EN: DN100 B2B_6; Type Id: HC_Boiler_MEPcontent_Elco_ThisionCascade_6 Boiler_Back to Back_DN100_INT-EN: DN100 B2B_6
Phasing - Phase Created: 3. Nieuwbouw
Visibility - Boiler: TH-L ECO-70
